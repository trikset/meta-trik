KERNEL_MODULE_PROBECONF +="cmemk"
module_conf_cmemk="options cmemk allowOverlap=1 phys_start=0xc8000000 phys_end=0xc9000000 pools=50x4096,10x131072,5x1440000"
