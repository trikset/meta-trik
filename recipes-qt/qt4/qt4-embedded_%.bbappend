QT_CONFIG_FLAGS += "-feature-qws-rotate-bgr"
OTHER_PACKAGES_remove += "qt4-embedded-demos"
