#Workaround/fix for build-deps QA warning.
DEPENDS += "libevdev"
