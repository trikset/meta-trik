#INHIBIT_PACKAGE_DEBUG_SPLIT = "1"
#INHIBIT_PACKAGE_STRIP = "1"
#DEBUG_BUILD = "1"
#OE_QMAKE_CXXFLAGS:append += " -ffunction-sections "
#EXTRA_QMAKEVARS_POST += "CONFIG+=ltcg CONFIG+=fat-lto"
#OE_QMAKE_CXXFLAGS:append += " -fno-lto " 

