# qtmultimedia fontconfig
PACKAGECONFIG = ""
CXXFLAGS += "-fpermissive"
