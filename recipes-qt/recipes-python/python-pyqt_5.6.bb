require python-pyqt.inc
SRC_URI[md5sum] = "dbfc885c0548e024ba5260c4f44e0481"
SRC_URI[sha256sum] = "2e481a6c4c41b96ed3b33449e5f9599987c63a5c8db93313bd57a6acbf20f0e1"
