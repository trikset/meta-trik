require python-pyqt.inc
SRC_URI[md5sum] = "ac04c0bfc1f05f5a1c2a1edd2640235c"
SRC_URI[sha256sum] = "9edf2816105a4111a447452df2bef7ce47d7efb307c75c3e74c27b8d31d7f66e"
