require reuse_patch.inc
