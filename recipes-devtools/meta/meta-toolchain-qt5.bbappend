TOOLCHAIN_HOST_TASK += "nativesdk-packagegroup-trik-toolchain-host"
TOOLCHAIN_TARGET_TASK += "packagegroup-trik-toolchain-target"
