require trik-image-core.bb

IMAGE_INSTALL += "\
		trik-ros \
		roslaunch \
		nodelet \
		"

