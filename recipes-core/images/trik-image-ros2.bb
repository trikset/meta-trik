require trik-image-base.inc

SUMMARY = "TRIK image with ROS2 Humble"

IMAGE_INSTALL += "\
    packagegroup-ros2-base \
"
