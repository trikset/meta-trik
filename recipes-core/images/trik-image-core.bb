require trik-image-base.inc


