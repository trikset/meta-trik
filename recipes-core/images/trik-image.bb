require trik-base-v2.bb

IMAGE_INSTALL += "\
packagegroup-multimedia \
		packagegroup-core-tools-debug \
"
