TUNE_FEATURES_remove = "arm926ejs"
