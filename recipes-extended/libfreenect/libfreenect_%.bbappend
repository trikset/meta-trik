DEPENDS_remove = "freeglut"
EXTRA_OECMAKE += " -DBUILD_EXAMPLES=OFF"

