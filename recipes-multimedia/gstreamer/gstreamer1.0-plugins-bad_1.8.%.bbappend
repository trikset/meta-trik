# This plugin requires kernel 3.10+
EXTRA_OECONF_append = " --disable-dvb "
