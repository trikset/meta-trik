INITSCRIPT_PARAMS="start 95 2 3 . stop 95 0 1 6 ."
