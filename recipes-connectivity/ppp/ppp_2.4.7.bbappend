FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://In6_h_include.patch"
