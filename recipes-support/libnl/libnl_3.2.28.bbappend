FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://001-No-in6-duplicates.patch"
