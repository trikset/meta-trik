PACKAGECONFIG = "--without-jack"
