FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://check_SYS_getrandom.patch"
