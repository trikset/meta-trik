#if gcc version < 6.0 there is no problem
PNBLACKLIST[espeak]=""
