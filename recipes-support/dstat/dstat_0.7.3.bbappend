#fix for morty build issue
DEPENDS += "xmlto-native"
