PACKAGECONFIG:class-native:remove += "directfb"
PACKAGECONFIG:class-native += "x11 xcb"
