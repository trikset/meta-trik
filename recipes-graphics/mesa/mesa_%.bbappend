PACKAGECONFIG += "gallium-llvm"
PACKAGECONFIG_remove_trikboard = "egl gles"
PROVIDES_remove_trikboard = "virtual/libgl virtual/libgles virtual/egl virtual/gles2"

