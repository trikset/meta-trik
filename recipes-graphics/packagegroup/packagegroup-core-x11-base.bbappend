RDEPENDS_${PN}_remove += "matchbox-terminal"
