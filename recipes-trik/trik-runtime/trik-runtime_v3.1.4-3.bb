require trik-runtime.inc