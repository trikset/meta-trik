require trik-runtime.inc

PR = "r1"
