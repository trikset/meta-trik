PR="r8"
require trik-runtime-qt4.inc

