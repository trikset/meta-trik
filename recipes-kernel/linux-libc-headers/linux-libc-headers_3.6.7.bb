require recipes-kernel/linux-libc-headers/linux-libc-headers.inc
SRC_URI[md5sum] = "089209f655c8811db20d8b6ff37a8093"
SRC_URI[sha256sum] = "7ddccd15a01b9b23affe44516ce0f45780e56eccc2a38471279851d42a803b22"
