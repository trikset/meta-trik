inherit autotools-brokensep
SRC_URI[md5sum] = "f6dcd5f4777cc6096678f770472c0a74"