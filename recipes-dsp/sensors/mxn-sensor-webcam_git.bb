require video-sensor-webcam-common.inc
SUMMARY		 = "TRIK MxN Sensor for webcam (arm + dsp binary parts)"

