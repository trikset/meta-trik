require video-sensor-ov7670-common.inc
SUMMARY		 = "TRIK MxN Sensor for ov7670 camera (arm + dsp binary parts)"

