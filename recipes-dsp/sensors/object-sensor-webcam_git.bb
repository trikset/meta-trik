SUMMARY		 = "TRIK Object Sensor for webcam (arm + dsp binary parts)"
require video-sensor-webcam-common.inc
