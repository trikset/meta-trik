require video-sensor-ov7670-common.inc
SUMMARY		 = "TRIK Line Sensor for ov7670 (arm + dsp binary parts)"

