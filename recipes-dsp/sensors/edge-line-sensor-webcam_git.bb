SUMMARY		 = "TRIK Line Sensor for webcam (arm + dsp binary parts)"
require video-sensor-webcam-common.inc
