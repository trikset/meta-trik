require video-sensor-ov7670-common.inc
SUMMARY		 = "TRIK mjpg encoder for ov7670 (arm + dsp binary parts)"

