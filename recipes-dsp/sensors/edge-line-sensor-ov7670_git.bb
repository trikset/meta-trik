require video-sensor-ov7670-common.inc
SUMMARY		 = "TRIK edge-detection line sensor for ov7670 (arm + dsp binary parts)"

