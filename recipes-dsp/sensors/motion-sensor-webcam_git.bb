require video-sensor-webcam-common.inc
SUMMARY		 = "TRIK motion sensor for webcam (arm + dsp binary parts)"

