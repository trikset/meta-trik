require video-sensor-ov7670-common.inc
SUMMARY		 = "TRIK motion sensor for ov7670 (arm + dsp binary parts)"

