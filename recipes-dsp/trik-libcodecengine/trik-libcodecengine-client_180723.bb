require trik-libcodecengine-client.inc

