#Hotfix. Remove it after meta-ros fixes this missing dependency
DEPENDS += "python-rospkg"
